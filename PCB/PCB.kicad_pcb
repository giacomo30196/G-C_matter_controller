# Repository giacomo30196/G-C_matter_controller

## KiCad design PCB/PCB.kicad_pcb

Board: 4 copper layers, 145.5 x 60.0 mm, 72 parts (0 on the bottom side), 52 nets, no tracks yet.

Parts:
C1: X7R 10 nF, 0603, 50 V, ±5%; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C5, C7, C9, C11, C13: 100nF 50V X7R ±5% 0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C6, C10, C12: 1uF 50V X7R ±10% 0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 10uF 25V X5R ±20% 0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C21: 4u7 50V 0805 X7R; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15: 22pF 50V C0G 0402; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C16, C18: 22uF 0805 10V X7R; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17: 100nF 50V X7R 0402; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C19, C20: 1uF 10V X7R 0402; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D3: SR70
D2, D4: CDSOD323-T15; CDSOD323T15
D5: LED GREEN; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: LED BLUE; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: ESDA25P35-1U1M; ESDA25P351U1M
FB2: 330Ohm@100MHz 0805; INDC2012X105N
IC1: GP8403-TC50-EW; SOP100P600X165-11N
IC2: TLV9061IDBVR; SOT95P280X145-5N
IC3: BC847BDW1T1G; SOT65P210X110-6N
IC4: MPM3510AGQV; QFN-19
J3: BM06B-GHS-TBT_LF__SN_; BM06BGHSTBTLFSN
J4: G-Switch GT-USB-7075A
NT1, NT2, NT3: NetTie_2; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
R1, R2: 100k 0603 0.1% 0.1W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 143k 0603 0.1% 0.1W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 47R 0603 5% 0.1W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1M 0603 0.1% 0.1W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R8: 0R 5% 0402 1/16W; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R9: 330R 0.1% 0603 1/10W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R20: 10K 5% 0603 1/10W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R14, R19, R22: 3K3 1% 0603 1/10W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13, R24, R28, R29, R30: 10K 1% 0402 1/16W; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R15, R16, R17, R18: 100R 1% 0402 1/16W; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21: 330R 1% 0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 220R 1% 0603; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25: 75K 0402 1% 62.5mW; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R26: 24K 0402 1% 62.5mW; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R27: 1M 0402 5% 62.5mW; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
S1: KSC221JLFS
U1: ESP32-C6-WROOM-1-N8; ESP32-C6-WROOM-1
U2: ESD7004MUTAG; UDFN10_CASE_517BB
U3: STUSB4500QTR; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm

Connections:
+3V3: C2.1, C3.2, C15.1, C16.1, C18.1, FB2.1, IC2.5 (V+), IC4.7 (OUT_1), IC4.8 (OUT_2), IC4.9 (OUT_3), R5.1, R14.1, R19.1, R20.2, R21.2, R23.2, R24.2, R25.1
+3V3_ESP: C8.1, C9.1, C12.2, FB2.2, R10.2, R11.1, U1.2 (3V3)
/0-10V Driver/SCL: IC1.1 (SCLK), R14.2, U1.7 (MTDO/GPIO7)
/0-10V Driver/SDA: IC1.2 (SDA), R19.2, U1.6 (MTCK/GPIO6/ADC1_CH6)
/0-10V Driver/VCC: C4.2, C7.1, IC1.5 (VCC)
/DCDC_stage/VIN: C14.1, C17.1, IC4.15 (IN), R27.1
/MCU/CHIP_PU: C10.2, IC3.3 (C1), IC4.17 (PG), R10.1, R24.1, U1.3 (EN/CHIP_PU)
/MCU/DTR: IC3.1 (E2), R13.1, R16.1
/MCU/GPIO1: C13.1, R4.1, R5.2, U1.9 (GPIO1/ADC1_CH1/XTAL_32K_N)
/MCU/GPIO4: R20.1, R22.1, U1.4 (MTMS/GPIO4/ADC1_CH4)
/MCU/GPIO8: R11.2, U1.10 (GPIO8)
/MCU/GPIO9: IC3.6 (C2), U1.15 (GPIO9)
/MCU/GPIO22: D5.1 (K), U1.20 (GPIO22)
/MCU/GPIO23: D6.1 (K), U1.21 (GPIO23)
/MCU/RTS: IC3.4 (E1), R12.2, R15.1
/MCU/UART_RXD: R17.1, U1.24 (U0RXD/GPIO17)
/MCU/UART_TXD: R18.1, U1.25 (U0TXD/GPIO16)
/USB_PD/2V7: C19.1, R28.2, R29.2, U3.23 (VREG_2V7)
/USB_PD/RESET: R30.2, U3.6 (RESET)
/USB_PD/SDA: U3.8 (SDA), U3.19 (ALERT)
/USB_PD/VBUS: C21.1, D7.1 (K), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), U3.24 (VDD)
GND: C4.1, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.1, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D1.1 (GND), D2.2 (A), D3.1 (GND), D4.2 (A), D7.2 (A), IC1.11 (EP), IC4.3 (AGND), IC4.12 (PGND_1), IC4.13 (PGND_2), J3.1, J3.MP1, J3.MP2, J4.1 (CASE), J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), NT1.2, NT2.2, NT3.2, R6.1, R7.1, R8.2, R26.2, R30.1, S1.4 (NO_2), U1.1 (GND), U1.28 (GND), U1.29 (GND), U2.3 (GND_1), U2.8 (GND_2), U3.1 (CC1DB), U3.5 (CC2DB), U3.10 (GND), U3.22 (VSYS), U3.25 (GND)
GNDA_1: C1.2, C2.2, C3.1, C13.2, IC2.2 (V-), NT1.1, R2.1
GNDA_2: C5.2, IC1.6 (GND), NT2.1
unnamed: C1.1, R1.2, R3.2
unnamed: C5.1, D1.2 (I/O_1), D4.1 (K), R9.2
unnamed: D2.1 (K), D3.2 (I/O_1), R1.1
unnamed: D5.2 (A), R21.1
unnamed: D6.2 (A), R23.1
unnamed: IC1.3 (A0), R6.2
unnamed: IC1.4 (A1), R7.2
unnamed: IC1.9 (A2), R8.1
unnamed: C6.1, IC1.10 (V5V)
unnamed: IC1.8 (VOUT0), R9.1
unnamed: IC2.3 (IN+), R2.2, R3.1
unnamed: IC2.1 (OUT), IC2.4 (IN-), R4.2
unnamed: IC3.5 (B1), R13.2
unnamed: IC3.2 (B2), R12.1
unnamed: IC4.16 (EN/SYNC), R27.2
unnamed: C15.2, IC4.1 (FB), R25.2, R26.1
unnamed: C11.1, R22.2, S1.3 (COM_2)
unnamed: R18.2, U2.1 (I/O_1)
unnamed: R17.2, U2.2 (I/O_2)
unnamed: R16.2, U2.4 (I/O_3)
unnamed: R15.2, U2.5 (I/O_4)
unnamed: J3.5, U2.6 (N/C_1)
unnamed: J3.4, U2.7 (N/C_2)
unnamed: J3.3, U2.9 (N/C_3)
unnamed: J3.2, U2.10 (N/C_4)
unnamed: R29.1, U3.12 (ADDR0)
unnamed: R28.1, U3.13 (ADDR1)
unnamed: C20.1, U3.21 (VREG_1V2)

## Commit log

2025-12-18 0-10V IN schematic
2025-12-21 fix to 0-10V IN schematic, 0-10V OUT schematic
2025-12-21 fix to 0-10v out.... idiot me :(
2025-12-21 minor fix, esp32 partial schematic
2025-12-26 esp32 various fix, 20to3v3 DCDC.
2025-12-27 stusb schematic
