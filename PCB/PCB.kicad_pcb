File: PCB/PCB.kicad_pcb (KiCad board)
At the start: 4 copper layers, 60 x 60 mm, 70 parts, among them IC1 GP8403-TC50-EW, IC2 GP8403-TC50-EW, IC3 TPS25947, Q1 STL6P3LLH6, Q2 STL6P3LLH6, Q3 STL6P3LLH6, Q4 STL6P3LLH6, U1 ESP32-C6-WROOM-1, U2 STUSB4500QTR, U3 STUSB4500QTR

Commit message: fix to 0-10V IN schematic, 0-10V OUT schematic
Parts:
- removed IC1: GP8403-TC50-EW, SamacSys_Parts:SOP100P600X165-11N
- removed IC3: TPS25947, SamacSys_Parts:TPS25947
- removed Q1, Q2, Q3, Q4: STL6P3LLH6, SamacSys_Parts:STL8N10F7
- removed R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33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: RC0603FR-07100KL, SamacSys_Parts:RESC1608X55N
- removed U1: ESP32-C6-WROOM-1, PCM_Espressif:ESP32-C6-WROOM-1
- removed U2, U3: STUSB4500QTR, Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm
- added C1: X7R 10 nF, 0603, 50 V, ±5%, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (112.1, 61.3)
- added C2: 100nF 16V X7R ±5% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (112.1, 63.8)
- added C3: 16V 1uF X7R ±5% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (112.1, 66.3)
- added D2: CDSOD323-T15, SamacSys_Parts:CDSOD323T15, F.Cu at (117.3, 62.3)
- IC2: value GP8403-TC50-EW -> TLV9061IDBVR; footprint SamacSys_Parts:SOP100P600X165-11N -> SamacSys_Parts:SOT95P280X145-5N
- R1, R2, R4: value RC0603FR-07100KL -> 100k 0603 0.1% 0.1W; footprint SamacSys_Parts:RESC1608X55N -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R3: value RC0603FR-07100KL -> 143k 0603 0.1% 0.1W; footprint SamacSys_Parts:RESC1608X55N -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R5: value RC0603FR-07100KL -> 1M 0603 0.1% 0.1W; footprint SamacSys_Parts:RESC1608X55N -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- moved IC2 42.6 mm to (116.9, 66.8)
- moved R1 26.5 mm to (112.1, 68.9)
- moved R2 26.5 mm to (112.1, 71.4)
- moved R3 26.5 mm to (112.1, 73.9)
- moved R4 26.5 mm to (112.1, 76.4)
- moved R5 26.5 mm to (112.1, 78.9)
Connections:
- IC2 pad 1: unconnected-(IC2-SCLK-Pad1) -> Net-(IC2-IN-)
- IC2 pad 2: unconnected-(IC2-SDA-Pad2) -> GNDA
- IC2 pad 3: unconnected-(IC2-A0-Pad3) -> Net-(IC2-IN+)
- IC2 pad 4: unconnected-(IC2-A1-Pad4) -> Net-(IC2-IN-)
- IC2 pad 5: unconnected-(IC2-VCC-Pad5) -> +3V3
- R1 pad 1: unconnected-(R1-Pad1) -> Net-(D2-K)
- R1 pad 2: unconnected-(R1-Pad2) -> Net-(C1-Pad1)
- R2 pad 1: unconnected-(R2-Pad1) -> GNDA
- R2 pad 2: unconnected-(R2-Pad2) -> Net-(IC2-IN+)
- R3 pad 1: unconnected-(R3-Pad1) -> Net-(IC2-IN+)
- R3 pad 2: unconnected-(R3-Pad2) -> Net-(C1-Pad1)
- R4 pad 1: unconnected-(R4-Pad1) -> V_SENSE_OUT
- R4 pad 2: unconnected-(R4-Pad2) -> Net-(IC2-IN-)
- R5 pad 1: unconnected-(R5-Pad1) -> +3V3
- R5 pad 2: unconnected-(R5-Pad2) -> V_SENSE_OUT

Commit message: minor fix, esp32 partial schematic
Parts:
- added C10: 1uF 50V X7R ±10% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (149.7, 59.5)
- added C2: 100nF 50V X7R ±5% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (153.5, 84.2)
- added C3: 1uF 50V X7R ±10% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (153.5, 86.7)
- added C4: 1uF 50V X7R ±10% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (129.0, 84.2)
- added C5: 100nF 50V X7R ±5% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (129.0, 86.7)
- added C6: 1uF 50V X7R ±10% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (129.0, 89.2)
- added C7: 100nF 50V X7R ±5% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (129.0, 91.7)
- added C8: 10uF 25V X5R ±20% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (149.7, 54.4)
- added C9: 100nF 50V X7R ±5% 0603, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (149.7, 56.9)
- added D1: SR70, SamacSys_Parts:SR70, F.Cu at (134.2, 92.8)
- added D3: SR70, SamacSys_Parts:SR70, F.Cu at (148.3, 86.2)
- added D4: CDSOD323-T15, SamacSys_Parts:CDSOD323T15, F.Cu at (140.3, 91.6)
- added IC1: GP8403-TC50-EW, SamacSys_Parts:SOP100P600X165-11N, F.Cu at (135.5, 86.2)
- added R6: 0R 5% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (141.4, 83.9)
- added R7: 0R 5% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (141.4, 85.9)
- added R8: 0R 5% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (141.4, 87.9)
- added U1: ESP32-C6-WROOM-1-N8, PCM_Espressif:ESP32-C6-WROOM-1, F.Cu at (137.2, 69.8)
- R4: value 100k 0603 0.1% 0.1W -> 47R 0603 5% 0.1W
Connections:
- net V_SENSE_OUT renamed /0-10V Input/V_SENSE_OUT
- D2 pad 2: GNDA -> GND

Commit message: esp32 various fix, 20to3v3 DCDC.
Parts:
- added IC3: BC847BDW1T1G, SamacSys_Parts:SOT65P210X110-6N, F.Cu at (170.1, 58.2)
- added J3: BM06B-GHS-TBT_LF__SN_, SamacSys_Parts:BM06BGHSTBTLFSN, F.Cu at (153.0, 75.6)
- added R12: 10K 1% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (166.2, 57.3)
- added R13: 10K 1% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (166.2, 59.3)
- added R15: 100R 1% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (166.2, 61.3)
- added R16: 100R 1% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (166.2, 63.3)
- added R17: 100R 1% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (166.2, 65.3)
- added R18: 100R 1% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (166.2, 67.3)
- added R20: 100R 1% 0402 1/16W, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, F.Cu at (167.8, 71.2)
- added U2: ESD7004MUTAG, SamacSys_Parts:UDFN10_CASE_517BB, F.Cu at (153.1, 69.9)
Connections:
- IC1 pad 1: /0-10V Driver/SCLK -> /0-10V Driver/SCL
- R4 pad 1: /0-10V Input/V_SENSE_OUT -> /MCU/GPIO1
- R5 pad 2: /0-10V Input/V_SENSE_OUT -> /MCU/GPIO1
- U1 pad 10: unconnected-(U1-GPIO8-Pad10) -> /MCU/GPIO8
- U1 pad 11: unconnected-(U1-GPIO10-Pad11) -> /MCU/GPIO10
- U1 pad 12: unconnected-(U1-GPIO11-Pad12) -> /MCU/GPIO11
- U1 pad 13: unconnected-(U1-GPIO12/USB_D--Pad13) -> /MCU/GPIO12
- U1 pad 14: unconnected-(U1-GPIO13/USB_D+-Pad14) -> /MCU/GPIO13
- U1 pad 15: unconnected-(U1-GPIO9-Pad15) -> /MCU/GPIO9
- U1 pad 16: unconnected-(U1-GPIO18-Pad16) -> /MCU/GPIO18
- U1 pad 17: unconnected-(U1-GPIO19-Pad17) -> /MCU/GPIO19
- U1 pad 18: unconnected-(U1-GPIO20-Pad18) -> /MCU/GPIO20
- U1 pad 19: unconnected-(U1-GPIO21-Pad19) -> /MCU/GPIO21
- U1 pad 20: unconnected-(U1-GPIO22-Pad20) -> /MCU/GPIO22
- U1 pad 21: unconnected-(U1-GPIO23-Pad21) -> /MCU/GPIO23
- U1 pad 23: unconnected-(U1-GPIO15-Pad23) -> /MCU/GPIO15
- U1 pad 24: unconnected-(U1-U0RXD/GPIO17-Pad24) -> /MCU/UART_RXD
- U1 pad 25: unconnected-(U1-U0TXD/GPIO16-Pad25) -> /MCU/UART_TXD
- U1 pad 26: unconnected-(U1-GPIO3/ADC1_CH3-Pad26) -> /MCU/GPIO3
- U1 pad 27: unconnected-(U1-GPIO2/ADC1_CH2-Pad27) -> /MCU/GPIO2
- U1 pad 4: unconnected-(U1-MTMS/GPIO4/ADC1_CH4-Pad4) -> /MCU/GPIO4
- U1 pad 5: unconnected-(U1-MTDI/GPIO5/ADC1_CH5-Pad5) -> /MCU/GPIO5
- U1 pad 6: unconnected-(U1-MTCK/GPIO6/ADC1_CH6-Pad6) -> /0-10V Driver/SDA
- U1 pad 7: unconnected-(U1-MTDO/GPIO7-Pad7) -> /0-10V Driver/SCL
- U1 pad 8: unconnected-(U1-GPIO0/ADC1_CH0/XTAL_32K_P-Pad8) -> /MCU/GPIO0
- U1 pad 9: unconnected-(U1-GPIO1/ADC1_CH1/XTAL_32K_N-Pad9) -> /MCU/GPIO1
